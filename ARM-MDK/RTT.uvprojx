# Keil uVision project RTT.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: AIR001Dev AirM2M
  pack: AirM2M.AIR001xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RTT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,AIR001_DEV,
  c include: ..\inc;..\AIR001xx_HAL_Driver\Inc;..\AIR001xx_HAL_Driver\Inc\Legacy;..\RTT\RTT;..\RTT\Config
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/User
    ../src/: air001xx_hal_msp.c air001xx_it.c main.c
  group Drivers/AIR001xx_HAL_Driver
    ../AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_cortex.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_tim.c air001xx_hal_tim_ex.c air001xx_hal_dma.c air001xx_hal_gpio.c air001xx_hal_uart.c air001xx_hal_usart.c air001xx_hal_pwr.c air001xx_hal_pwr_ex.c
  group RTT
    ../RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.0.1
